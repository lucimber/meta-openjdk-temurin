require openjdk-8-native.inc

SUMMARY = "Prebuilt OpenJDK JDK for Java 8 offered by Adoptium."
DESCRIPTION = "OpenJDK 8 Java Development Kit for native builds."

API_IMAGE_TYPE = "jdk"
JVM_CHECKSUM:aarch64 = "af98a839ec238106078bd360af9e405dc6665c05ee837178ed13b92193681923"
JVM_CHECKSUM:arm = "5bd0203b2b09b033e3a762299a4975939d7571b433eab8b59340cc966102bef1"
JVM_CHECKSUM:x86-64 = "4c6056f6167fae73ace7c3080b78940be5c87d54f5b08894b3517eed1cbb2c06"
JVM_SRC_CHECKSUM = "ed95a098f1036b1300d6a6470f77b3445c02d2994e4d6ef8ef991183129cda80"

