require openjdk-8-native.inc

SUMMARY = "Prebuilt OpenJDK JDK for Java 8 offered by Adoptium."
DESCRIPTION = "OpenJDK 8 Java Development Kit for native builds."

API_IMAGE_TYPE = "jdk"
JVM_CHECKSUM:aarch64 = "ada72fbf191fb287b4c1e54be372b64c40c27c2ffbfa01f880c92af11f4e7c94"
JVM_CHECKSUM:arm = "1d0d16394e2fe637f9eb8e73e63ea6fe9ceee98337c0527aa058cee777ad638a"
JVM_CHECKSUM:x86-64 = "e74becad56b4cc01f1556a671e578d3788789f5257f9499f6fbed84e63a55ecf"
JVM_SRC_CHECKSUM = "5685fa2e9c1dff2e62010f389001f5ec6ab5df14f64c4cd4371f522157cf0025"

