require openjdk-11-native.inc

SUMMARY = "Prebuilt OpenJDK JDK for Java 11 offered by Adoptium."
DESCRIPTION = "OpenJDK 11 Java Development Kit for native builds."

API_IMAGE_TYPE = "jdk"
JVM_CHECKSUM:aarch64 = "60b0fb79bb678b6fae3e499c7b0a353e68633ed0ab69d1a6bafe6092ed1e59e4"
JVM_CHECKSUM:arm = "61b540e26de94600b2034a07a75492790f873bffd8664f0960ce88cd9e15feca"
JVM_CHECKSUM:x86-64 = "c4b8eaf56c93b95b689ffc08d155df1bcdbbffb666f8f71d21d97aedaea6f0ec"
JVM_SRC_CHECKSUM = "9611b9f4531dc003b1583ed531a71234e4cadb2dddbd4f79b2de0b339a8d4fa6"
