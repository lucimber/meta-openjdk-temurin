require openjdk-17.inc
SUMMARY = "Prebuilt OpenJDK JRE for Java 17 offered by Adoptium."

JVM_CHECKSUM:aarch64 = "9dfe4c56463690ae67d22268980d8861eb46b907d7914f8f2e6fc7b25778c8ec"
JVM_CHECKSUM:arm = "f093094abe0cb2bb5a255d8180810030321073520541f289926c4682eda76136"
JVM_CHECKSUM:x86-64 = "0e8088d7a3a7496faba7ac8787db09dc0264c2bc6f568ea8024fd775a783e13c"
JVM_CHECKSUM:riscv64 = "2d1ed42918305a1a0754a6e1e9294c7d4d7fda4bff6dba7bc5682037d860dbc9"

API_IMAGE_TYPE = "jre"
