require openjdk-17-native.inc

SUMMARY = "Prebuilt OpenJDK JDK for Java 17 offered by Adoptium."
DESCRIPTION = "OpenJDK 17 Java Development Kit for native builds."

API_IMAGE_TYPE = "jdk"
JVM_CHECKSUM:aarch64 = "8257de06bf37f0c8f19f8d542e2ab5a4e17db3ca5f29d041bd0b02ab265db021"
JVM_CHECKSUM:arm = "ce7873ebf40ed0eb1089941ead4d3af79a205b1264f3162860d26ae957572b74"
JVM_CHECKSUM:x86-64 = "9d4dd339bf7e6a9dcba8347661603b74c61ab2a5083ae67bf76da6285da8a778"
JVM_CHECKSUM:riscv64 = "d024c100eba4709970716ddcac757ba5e3122a8ff9c6f539ff8bac5b47f51f3a"
JVM_SRC_CHECKSUM = "bbc5fe161ea3aad2aad855a7954927d18bbdce1d74d14f2922a85ca50a74fec5"
