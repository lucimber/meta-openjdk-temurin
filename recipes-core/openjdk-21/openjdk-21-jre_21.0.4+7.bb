require openjdk-21.inc
SUMMARY = "Prebuilt OpenJDK JRE for Java 21 offered by Adoptium."

JVM_CHECKSUM:aarch64 = "58845ce4275f3ec74fba075597c8216bb201773da036c4703be8b7b7b457355d"
JVM_CHECKSUM:x86-64 = "d3affbb011ca6c722948f6345d15eba09bded33f9947d4d67e09723e2518c12a"
JVM_CHECKSUM:riscv64 = "bf814344429f53d11f8aace14d326e2580ea6e66dd81b109c79160bd41735237"

API_IMAGE_TYPE = "jre"

