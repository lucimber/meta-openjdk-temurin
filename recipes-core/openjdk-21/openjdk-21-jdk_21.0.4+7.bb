require openjdk-21.inc
require openjdk-21-jdk.inc

